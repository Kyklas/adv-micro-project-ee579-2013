# IAR project Assingment 4.ewp, settings and files
configuration Debug (M16C, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlm16cnnnfwwf.h
  General.GData16HeapSize: 0x400
  General.GFarHeapSize: 0x400
  General.GData20HeapSize: 0x400
  General.GStackSize: 0x80
  General.GIStackSize: 0x40
  General.OGChipSelectMenu: M30626FJP M30626FJP
  ICCM16C.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkM30626FJP.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XlinkInterruptStackSize: 1
configuration Release (M16C)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
