<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Assignment 4 - Chris Morrison 200805572.ewp</path>
  </project>
  <batchBuild/>
</workspace>


